
COMPATIBLE_MACHINE_fsref = "fsref"
