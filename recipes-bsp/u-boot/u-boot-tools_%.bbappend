
# change to my own server
SRC_URI = "git://${DEV_SRV_URL}/official/u-boot.git;protocol=file;branch=master"
