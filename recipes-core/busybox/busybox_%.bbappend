FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
# name it according busybox_%.bb in poky
SRC_URI += "file://machine.cfg \
"
