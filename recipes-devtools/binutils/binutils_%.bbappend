
BINUTILS_GIT_URI ?= "${GITHUB_MIRROR}/sourceware.org/binutils-gdb.git;branch=${SRCBRANCH};protocol=${GITHUB_PROTOCOL}"
