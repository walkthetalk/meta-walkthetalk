# disable python which is enabled in qt5-layer by default
PACKAGECONFIG = "readline"
