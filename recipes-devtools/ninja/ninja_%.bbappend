
SRC_URI = "${GITHUB_MIRROR}/ninja-build/ninja.git;branch=release;protocol=${GITHUB_PROTOCOL}"
