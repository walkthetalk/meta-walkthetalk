
SRC_URI = "${GITHUB_MIRROR}/NixOS/patchelf.git;branch=master;protocol=${GITHUB_PROTOCOL}"
