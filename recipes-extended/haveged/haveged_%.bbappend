SRC_URI = "${GITHUB_MIRROR}/jirka-h/haveged.git;branch=master;protocol=${GITHUB_PROTOCOL}"
