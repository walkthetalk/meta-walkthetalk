include nvidia-base.inc
include nvidia-kernel-module.inc
include nvidia-libs.inc

SRC_URI[md5sum] = "784e4b8b84d62b0342d4106cb4cb4de5"
SRC_URI[sha256sum] = "841d69fe1426883647112bb070fe2f29a1f849c64ac80a8d61c70970d8d3d522"
