FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://insertAtFirstVisibleItem.patch \
"
