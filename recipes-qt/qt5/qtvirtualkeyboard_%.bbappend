PACKAGECONFIG[arrow-key-navigation] = "CONFIG+=arrow-key-navigation"
PACKAGECONFIG[handwriting] = "CONFIG+=handwriting"
PACKAGECONFIG_append_kl360 = " handwriting arrow-key-navigation"
PACKAGECONFIG_append_fsref = " handwriting arrow-key-navigation"
