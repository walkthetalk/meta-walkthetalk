include gsl.inc

SRC_URI = "https://ftp.gnu.org/gnu/gsl/gsl-${PV}.tar.gz"
SRC_URI[sha256sum] = "dcb0fbd43048832b757ff9942691a8dd70026d5da0ff85601e52687f6deeb34b"
