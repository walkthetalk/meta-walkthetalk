
SRC_URI = "${GITHUB_MIRROR}/opencv/ade.git;protocol=${GITHUB_PROTOCOL}"
